# Repository CHAPARII/CutieBoard

File README.md:

# CutieBoard

This is my 65% keyboard which I've made. This took lot of time and effort but eventualy it's done.

 This contains v2 microcontroller, custom PCB, matrix wiring with diodes, USBC connectivity, and programmable firmware. 
 To use this , i will assemble all the parts and flash the included firmware onto the microcontroller. Once assembled and programmed, the keyboard functions as a fully customizable mechanical keyboard.

 I made this project because once when I visited my friend's house I saw his 60% keyboard and it loocked really nice and after I got the motivation to make my own and i made 5%bigger mean 65% kerboard for myself T_T.

 Assemble and source file was exceeding the git hub limit so I uploaded it in drive.. here's the link:

Assembly:

https://drive.google.com/file/d/10Secn6sTEy_YUBc2IC5S-Infav-jlVgP/view?usp=sharing

Source file:

https://drive.google.com/file/d/1TsiWUpYD7Me1Dc-eUxpzGdPIGhlKXmdZ/view?usp=sharing

# Images

# Cart SS

# Important note:

Assemble and source file was exceeding the git hub limit so I uploaded it in drive.. here's the link:

Assembly:

https://drive.google.com/file/d/10Secn6sTEy_YUBc2IC5S-Infav-jlVgP/view?usp=sharing

Source file:

https://drive.google.com/file/d/1TsiWUpYD7Me1Dc-eUxpzGdPIGhlKXmdZ/view?usp=sharing

## Bill of Materials (BOM)

| Item | Product | Price (₹) | Link |
|------|--------|----------|------|
| Microcontroller | SuperMini nRF52840 Pro Micro BLE | ₹686 | https://robokits.co.in/iot-wireless-solutions/iot-internet-of-things/iot-esp-module/supermini-nrf52840-pro-micro-bluetooth-le-ble-controller-arduino-compatible |
| Key Switches | TTC Low Profile Brown Switches | ₹2880 | https://stackskb.com/store/ttc-low-profile-brown-switches-tactile/ |
| Keycaps | PBT Keycap Set (MX Compatible) | ₹2108 | https://amzn.in/d/030hoeA0 |
| Diodes | 1N4148 Diode Pack | ₹295 | https://amzn.in/d/060HajRJ |
| Battery | 3.7V LiPo Battery | ₹439 | https://amzn.in/d/0hRIfuOJ |
| Stabilizers | Cherry Screw-in Stabilizers | ₹999 | https://www.keebsmod.com/products/cherry-clip-in-stabilizers |
| PCB | Custom PCB (JLCPCB) | ₹2742 | — |

## Total Cost

**₹9,501** ($102.80 USD)

## KiCad design pcb/KeyBoard.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric
C2, C5, C6: 0.1uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79: 1N4148W; D_SOD-123
J1: Conn_01x02_Socket; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R1, R6, R7, R8, R9, R10, R11: 10K; R_0603_1608Metric
R2, R3, R4, R5: 4.7K; R_0603_1608Metric
SW1, SW14, SW29, SW42: SW_Push_45deg; Kailh-PG1353-Hotswap-1.5U
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW57, SW58, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66, SW68, SW73, SW74, SW75, SW76, SW77, SW78: SW_Push_45deg; Kailh-PG1353-Hotswap-1U
SW28: SW_Push_45deg; Kailh-PG1353-Hotswap-2U
SW43, SW67: SW_Push_45deg; Kailh-PG1353-Hotswap-1.75U
SW55, SW56: SW_Push_45deg; Kailh-PG1353-Hotswap-2.25U
SW69, SW70, SW71: SW_Push_45deg; Kailh-PG1353-Hotswap-1.25U
SW72: SW_Push_45deg; Kailh-PG1353-Hotswap-6.25U
SW93, SW94: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW95: SW_SPDT; MSK-12C02
U1: nice!nanov2
U2: ST7789_Module
U3, U4: MCP23017_SO; SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
+3V3: C1.1, C2.1, C5.1, C6.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, U1.22 (3.3V), U2.8 (BLK), U3.15 (A0), U3.18 (~RESET), U4.18 (~RESET)
COL1: SW1.1, SW15.1, SW29.1, SW43.1, SW56.1, SW69.1, U3.21 (GPA0)
COL2: SW2.1, SW16.1, SW30.1, SW44.1, SW57.1, SW70.1, U3.22 (GPA1)
COL3: SW3.1, SW17.1, SW31.1, SW45.1, SW58.1, SW71.1, U3.23 (GPA2)
COL4: SW4.1, SW18.1, SW32.1, SW46.1, SW59.1, SW72.1, U3.24 (GPA3)
COL5: SW5.1, SW19.1, SW33.1, SW47.1, SW60.1, SW73.1, U3.25 (GPA4)
COL6: SW6.1, SW20.1, SW34.1, SW48.1, SW61.1, SW74.1, U3.26 (GPA5)
COL7: SW7.1, SW21.1, SW35.1, SW49.1, SW62.1, SW75.1, U3.27 (GPA6)
COL8: SW8.1, SW22.1, SW36.1, SW50.1, SW63.1, SW76.1, U3.28 (GPA7)
COL9: SW9.1, SW23.1, SW37.1, SW51.1, SW64.1, SW77.1, U3.1 (GPB0)
COL10: SW10.1, SW24.1, SW38.1, SW52.1, SW65.1, SW78.1, U3.2 (GPB1)
COL11: SW11.1, SW25.1, SW39.1, SW53.1, SW66.1, U3.3 (GPB2)
COL12: SW12.1, SW26.1, SW40.1, SW54.1, SW67.1, U3.4 (GPB3)
COL13: SW13.1, SW27.1, SW41.1, SW55.1, SW68.1, U3.5 (GPB4)
COL14: SW14.1, SW28.1, SW42.1, U3.6 (GPB5)
DC: U1.12 (IO8), U2.6 (DC)
GND: C1.2, C2.2, C5.2, C6.2, SW93.C, SW93.S2, SW94.C, SW94.S2, SW95.2 (B), U1.1 (GND), U1.4 (GND), U1.5 (GND), U2.1 (GND), U2.2 (VCC), U3.9 (VDD), U3.10 (VSS), U3.16 (A1), U3.17 (A2), U4.9 (VDD), U4.10 (VSS), U4.15 (A0), U4.16 (A1), U4.17 (A2)
IO0: U1.3 (IO0), U4.20 (INTA)
IO1: U1.2 (IO1), U4.19 (INTB)
IO6: U1.10 (IO6), U3.19 (INTB)
IO7: U1.11 (IO7), U3.20 (INTA)
IO10: U1.14 (IO10), U2.7 (CS)
IO14: R8.2, SW94.A, U1.16 (IO14)
IO15: R1.2, U1.17 (IO15), U2.5 (RES)
IO16: SW93.S1, U1.15 (IO16)
IO18: R7.2, SW93.B, U1.18 (IO18)
IO19: R6.2, SW93.A, U1.19 (IO19)
IO20: R9.2, SW94.B, U1.20 (IO20)
IO21: SW94.S1, U1.21 (IO21)
MOSI: U1.8 (IO4), U2.4 (SDA)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2
unnamed: D60.2 (A), SW60.2
unnamed: D61.2 (A), SW61.2
unnamed: D62.2 (A), SW62.2
unnamed: D63.2 (A), SW63.2
unnamed: D64.2 (A), SW64.2
unnamed: D65.2 (A), SW65.2
unnamed: D66.2 (A), SW66.2
unnamed: D67.2 (A), SW67.2
unnamed: D68.2 (A), SW68.2
unnamed: D70.2 (A), SW69.2
unnamed: D71.2 (A), SW70.2
unnamed: D72.2 (A), SW71.2
unnamed: D73.2 (A), SW72.2
unnamed: D74.2 (A), SW73.2
unnamed: D75.2 (A), SW74.2
unnamed: D76.2 (A), SW75.2
unnamed: D77.2 (A), SW76.2
unnamed: D78.2 (A), SW77.2
unnamed: D79.2 (A), SW78.2
unnamed: J1.1, U1.25 (BATT+)
unnamed: J1.2, U1.24 (GND)
ROW1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U4.21 (GPA0)
ROW2: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), U4.22 (GPA1)
ROW3: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U4.23 (GPA2)
ROW4: D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), U4.24 (GPA3)
ROW5: D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), U4.25 (GPA4)
ROW6: D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), U4.26 (GPA5)
SCK: U1.9 (IO5), U2.3 (SCL)
SCL: R3.2, R5.2, U1.7 (IO3), U3.12 (SCK), U4.12 (SCK)
SDA: R2.2, R4.2, U1.6 (IO2), U3.13 (SDA), U4.13 (SDA)
SWITCH_BLE: R11.2, SW95.3 (C), U4.28 (GPA7)
SWITCH_USB: R10.2, SW95.1 (A), U4.27 (GPA6)

Board: 2 copper layers, 338.3 x 116.8 mm, 179 parts (78 on the bottom side), 121 nets.

## Commit log

2026-03-17 Include links to assembly and source files
    Added links to assembly and source files hosted on Google Drive due to GitHub file size limits.
2026-03-18 Create BOM.csv with component details and pricing
    Added a Bill of Materials (BOM) with components and costs.
